# Keil uVision project DeepLearn.uvprojx, settings and files
target DeepLearn (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: DeepLearn +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Inc;     ..\..\MyFun\NUMPY;     ..\..\MyFun;     ..\..\MyFun\malloc;     ..\..\MyFun\minist_read;     ..\..\MyFun\GradientDescent;F:/MyWork/My32Work/Repository-STM32CUBE/STM32Cube_FW_F4_V1.21.0/Drivers/STM32F4xx_HAL_Driver/Inc;F:/MyWork/My32Work/Repository-STM32CUBE/STM32Cube_FW_F4_V1.21.0/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;F:/MyWork/My32Work/Repository-STM32CUBE/STM32Cube_FW_F4_V1.21.0/Drivers/CMSIS/Device/ST/STM32F4xx/Include;F:/MyWork/My32Work/Repository-STM32CUBE/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/FatFs/src;F:/MyWork/My32Work/Repository-STM32CUBE/STM32Cube_FW_F4_V1.21.0/Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group numpy
    ../../MyFun/NUMPY/: numpy.c matrix.c
    ../../MyFun/minist_read/: minist.c
    ../../MyFun/GradientDescent/: GradientDescent.c
  group malloc
    ../../MyFun/malloc/: CUI_MALLOC.C
  group Application/User
    ../Src/: main.c gpio.c dma.c bsp_driver_sd.c sd_diskio.c fatfs.c sdio.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    F:/MyWork/My32Work/Repository-STM32CUBE/STM32Cube_FW_F4_V1.21.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Middlewares/FatFs
    F:/MyWork/My32Work/Repository-STM32CUBE/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/FatFs/src/option/: syscall.c
    F:/MyWork/My32Work/Repository-STM32CUBE/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
software components: CMSIS:CORE 4.3.0
